options:
  parameters:
    author: Davydov Denis
    generate_options: no_gui
    id: simulation_test_grc_new_version
    max_nouts: int(50e-3*samp_rate)
    output_language: python
    run_options: run
    title: HF channel simulation
  states: {}

blocks:
- name: ampl
  id: variable
  parameters:
    value: '[[1.0, 1.0], [1.0, 1.0]]'
  states: {}
- name: doppler_ir
  id: variable
  parameters:
    value: '[0.0016502763167573274, 0.0018854799389366934, 0.002149957633383614, 0.0024466994528029662, 0.002778907461425479, 0.003149998028185868, 0.003563602180973301, 0.00402356375450247, 0.004533935060796761, 0.0050989698117900155, 0.005723113028669535, 0.006410987682800636, 0.007167377828853199, 0.007997208012493867, 0.008905518763040982, 0.00989743801603955, 0.010978148351927763, 0.012152849984840378, 0.013426719489994542, 0.014804864318746317, 0.016292273216847054, 0.01789376273305468, 0.019613920081278834, 0.021457042698902442, 0.023427074925696508, 0.025527542310538734, 0.027761484135525694, 0.030131384827462734, 0.03263910500345486, 0.035285812968654906, 0.03807191754835305, 0.04099700319171279, 0.04405976832879332, 0.04725796799434838, 0.050588361749672524, 0.05404666793605477, 0.057627525278984175, 0.06132446283016882, 0.06512987918400244, 0.0690350318359975, 0.073030037462906, 0.07710388379815894, 0.08124445365265866, 0.08543856149104095, 0.08967200281887802, 0.0939296164688993, 0.09819535969651079, 0.10245239580938088, 0.10668319386560887, 0.1108696397832219, 0.11499315801386097, 0.11903484274903825, 0.12297559745183839, 0.12679628134392928, 0.1304778613306593, 0.13400156771907581, 0.1373490519778611, 0.14050254470705797, 0.14344501193124823, 0.14616030780428022, 0.14863332181791858, 0.15085011864154488, 0.1527980687853246, 0.154465968374505, 0.15584414644656272, 0.15692455833401583, 0.15770086387153975, 0.1581684893637365, 0.15832467246620405, 0.1581684893637365, 0.15770086387153975, 0.15692455833401583, 0.15584414644656272, 0.154465968374505, 0.1527980687853246, 0.15085011864154488, 0.14863332181791858, 0.14616030780428022, 0.14344501193124823, 0.14050254470705797, 0.1373490519778611, 0.13400156771907581, 0.1304778613306593, 0.12679628134392928, 0.12297559745183839, 0.11903484274903825, 0.11499315801386097, 0.1108696397832219, 0.10668319386560887, 0.10245239580938088, 0.09819535969651079, 0.0939296164688993, 0.08967200281887802, 0.08543856149104095, 0.08124445365265866, 0.07710388379815894, 0.073030037462906, 0.0690350318359975, 0.06512987918400244, 0.06132446283016882, 0.057627525278984175, 0.05404666793605477, 0.050588361749672524, 0.04725796799434838, 0.04405976832879332, 0.04099700319171279, 0.03807191754835305, 0.035285812968654906, 0.03263910500345486, 0.030131384827462734, 0.027761484135525694, 0.025527542310538734, 0.023427074925696508, 0.021457042698902442, 0.019613920081278834, 0.01789376273305468, 0.016292273216847054, 0.014804864318746317, 0.013426719489994542, 0.012152849984840378, 0.010978148351927763, 0.00989743801603955, 0.008905518763040982, 0.007997208012493867, 0.007167377828853199, 0.006410987682800636, 0.005723113028669535, 0.0050989698117900155, 0.004533935060796761, 0.00402356375450247, 0.003563602180973301, 0.003149998028185868, 0.002778907461425479, 0.0024466994528029662, 0.002149957633383614, 0.0018854799389366934, 0.0016502763167573274]'
  states: {}
- name: en_noise
  id: variable
  parameters:
    value: '[0,0]'
  states: {}
- name: fd
  id: variable
  parameters:
    value: '1'
  states: {}
- name: freqShift
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: kN
  id: variable
  parameters:
    value: pow(10.0, (-snr/20.0))
  states: {}
- name: noSpread
  id: variable
  parameters:
    value: '1'
  states: {}
- name: outSigRMSVec
  id: variable_function_probe
  parameters:
    block_id: outSigRMS
    function_name: level
    poll_rate: '10'
    value: ([0]*2)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: snr
  id: variable
  parameters:
    value: '40'
  states: {}
- name: snrVecOut
  id: variable_function_probe
  parameters:
    block_id: snrOut
    function_name: level
    poll_rate: '10'
    value: ([0]*3)
  states: {}
- name: tau
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: tau_a
  id: variable
  parameters:
    value: 1/100.
  states: {}
- name: vol
  id: variable
  parameters:
    value: '[1,1]'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: ampl[0][0]
    type: complex
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: ampl[0][1]
    type: complex
  states: {}
- name: analog_const_source_x_1_0_0
  id: analog_const_source_x
  parameters:
    const: ampl[1][1]
    type: complex
  states: {}
- name: analog_const_source_x_1_1
  id: analog_const_source_x
  parameters:
    const: ampl[1][0]
    type: complex
  states: {}
- name: analog_const_source_x_2
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_2_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.3'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {}
- name: analog_fastnoise_source_x_1
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_fastnoise_source_x_2
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '1'
    type: complex
  states: {}
- name: analog_fastnoise_source_x_3
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '10'
    type: complex
  states: {}
- name: analog_fastnoise_source_x_4
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '11'
    type: complex
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: 1e-0*kN
    noise_type: analog.GR_GAUSSIAN
    seed: '3'
    type: complex
  states: {}
- name: analog_noise_source_x_1_0
  id: analog_noise_source_x
  parameters:
    amp: 1e-0*kN
    noise_type: analog.GR_GAUSSIAN
    seed: '13'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 0.5 / 2 * 0.8
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1850'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1850'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1850'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1850'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: 1000 + 1000
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freqShift
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freqShift
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1850'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1850'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:CARD=USB,DEV=0
    num_inputs: '2'
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_1
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:CARD=USB,DEV=0
    num_outputs: '2'
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_1
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_2
  id: audio_source
  parameters:
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_2_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_2_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_2_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(tau*samp_rate)
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(tau*samp_rate)
    type: complex
  states: {}
- name: blocks_divide_xx_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_1_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 2 * sqrt(ampl[0][0]**2 + ampl[0][1]**2)*2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2 * sqrt(ampl[1][0]**2 + ampl[1][1]**2)*2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: vol[0]
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol[1]
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: en_noise[0]
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: en_noise[1]
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    num_outputs: '2'
    type: float
  states: {state: disabled}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: 2*pi*tau_a*100/samp_rate
    type: complex
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: 2*pi*tau_a*10/samp_rate
    type: float
  states: {}
- name: blocks_rms_xx_0_0_0
  id: blocks_rms_xx
  parameters:
    alpha: 2*pi*tau_a*10/samp_rate
    type: float
  states: {}
- name: blocks_rms_xx_0_1
  id: blocks_rms_xx
  parameters:
    alpha: 2*pi*tau_a*100/samp_rate
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: noSpread
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: noSpread
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: noSpread
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: noSpread
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '4'
    type: float
  states: {}
- name: blocks_streams_to_vector_0_0
  id: blocks_streams_to_vector
  parameters:
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nfrom math import log, sqrt, exp, pi\nimport scipy\nfrom scipy.signal import lfilter, lfilter_zi\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, fd=0.1):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Prefilled Selfmade filter',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n\n        fs = 100.0\n        N = int( sqrt( -log( 0.01,exp(1.0) ) ) / (pi*fd/fs) )\n        n = range(-N, N+1)\n        z = np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N) + np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N)*1j\n        #scipy.fromfile(open(\"complex_noise_4095_samples\"), dtype=scipy.complex64)\n\n        h = list(map (lambda n : exp(-(pi*fd*n/fs)**2), n))\n        \n        k = sqrt(sum(map(lambda x: x*x, h)))\n        self.doppler_ir = list(map(lambda x: x / k, h))\n        self.N = N\n        _, self.z_init = lfilter(self.doppler_ir, 1.0, z[:2*N], zi = z[:2*N])\n        #self.z_init = lfilter_zi(self.doppler_ir, 1.0)\n        #self.z_init = z[:2*N]\n        #self.z_init = np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N) + np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N)*1j\n        self.z_end = list()  # holds the final filter delay values.\n\n    def work(self, input_items, output_items):\n        #output_items[0][:], self.z_end = lfilter(self.doppler_ir, 1.0, input_items[0], zi = self.z_init)\n        if len(self.z_end) == 0:\n            output_items[0][:], self.z_end = lfilter(self.doppler_ir, 1.0, input_items[0], zi = self.z_init)\n        else:\n            output_items[0][:], self.z_end = lfilter(self.doppler_ir, 1.0, input_items[0], zi = self.z_end)\n        return len(output_items[0])\n        \n"
    fd: fd
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nfrom math import log, sqrt, exp, pi\nimport scipy\nfrom scipy.signal import lfilter, lfilter_zi\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, fd=0.1):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Prefilled Selfmade filter',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n\n        fs = 100.0\n        N = int( sqrt( -log( 0.01,exp(1.0) ) ) / (pi*fd/fs) )\n        n = range(-N, N+1)\n        z = np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N) + np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N)*1j\n        #scipy.fromfile(open(\"complex_noise_4095_samples\"), dtype=scipy.complex64)\n\n        h = list(map (lambda n : exp(-(pi*fd*n/fs)**2), n))\n        \n        k = sqrt(sum(map(lambda x: x*x, h)))\n        self.doppler_ir = list(map(lambda x: x / k, h))\n        self.N = N\n        _, self.z_init = lfilter(self.doppler_ir, 1.0, z[:2*N], zi = z[:2*N])\n        #self.z_init = lfilter_zi(self.doppler_ir, 1.0)\n        #self.z_init = z[:2*N]\n        #self.z_init = np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N) + np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N)*1j\n        self.z_end = list()  # holds the final filter delay values.\n\n    def work(self, input_items, output_items):\n        #output_items[0][:], self.z_end = lfilter(self.doppler_ir, 1.0, input_items[0], zi = self.z_init)\n        if len(self.z_end) == 0:\n            output_items[0][:], self.z_end = lfilter(self.doppler_ir, 1.0, input_items[0], zi = self.z_init)\n        else:\n            output_items[0][:], self.z_end = lfilter(self.doppler_ir, 1.0, input_items[0], zi = self.z_end)\n        return len(output_items[0])\n        \n"
    fd: fd
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nfrom math import log, sqrt, exp, pi\nimport scipy\nfrom scipy.signal import lfilter, lfilter_zi\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, fd=0.1):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Prefilled Selfmade filter',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n\n        fs = 100.0\n        N = int( sqrt( -log( 0.01,exp(1.0) ) ) / (pi*fd/fs) )\n        n = range(-N, N+1)\n        z = np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N) + np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N)*1j\n        #scipy.fromfile(open(\"complex_noise_4095_samples\"), dtype=scipy.complex64)\n\n        h = list(map (lambda n : exp(-(pi*fd*n/fs)**2), n))\n        \n        k = sqrt(sum(map(lambda x: x*x, h)))\n        self.doppler_ir = list(map(lambda x: x / k, h))\n        self.N = N\n        _, self.z_init = lfilter(self.doppler_ir, 1.0, z[:2*N], zi = z[:2*N])\n        #self.z_init = lfilter_zi(self.doppler_ir, 1.0)\n        #self.z_init = z[:2*N]\n        #self.z_init = np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N) + np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N)*1j\n        self.z_end = list()  # holds the final filter delay values.\n\n    def work(self, input_items, output_items):\n        #output_items[0][:], self.z_end = lfilter(self.doppler_ir, 1.0, input_items[0], zi = self.z_init)\n        if len(self.z_end) == 0:\n            output_items[0][:], self.z_end = lfilter(self.doppler_ir, 1.0, input_items[0], zi = self.z_init)\n        else:\n            output_items[0][:], self.z_end = lfilter(self.doppler_ir, 1.0, input_items[0], zi = self.z_end)\n        return len(output_items[0])\n        \n"
    fd: fd
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nfrom math import log, sqrt, exp, pi\nimport scipy\nfrom scipy.signal import lfilter, lfilter_zi\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, fd=0.1):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Prefilled Selfmade filter',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n\n        fs = 100.0\n        N = int( sqrt( -log( 0.01,exp(1.0) ) ) / (pi*fd/fs) )\n        n = range(-N, N+1)\n        z = np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N) + np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N)*1j\n        #scipy.fromfile(open(\"complex_noise_4095_samples\"), dtype=scipy.complex64)\n\n        h = list(map (lambda n : exp(-(pi*fd*n/fs)**2), n))\n        \n        k = sqrt(sum(map(lambda x: x*x, h)))\n        self.doppler_ir = list(map(lambda x: x / k, h))\n        self.N = N\n        _, self.z_init = lfilter(self.doppler_ir, 1.0, z[:2*N], zi = z[:2*N])\n        #self.z_init = lfilter_zi(self.doppler_ir, 1.0)\n        #self.z_init = z[:2*N]\n        #self.z_init = np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N) + np.random.normal(loc=0, scale=np.sqrt(2)/2, size=2*N)*1j\n        self.z_end = list()  # holds the final filter delay values.\n\n    def work(self, input_items, output_items):\n        #output_items[0][:], self.z_end = lfilter(self.doppler_ir, 1.0, input_items[0], zi = self.z_init)\n        if len(self.z_end) == 0:\n            output_items[0][:], self.z_end = lfilter(self.doppler_ir, 1.0, input_items[0], zi = self.z_init)\n        else:\n            output_items[0][:], self.z_end = lfilter(self.doppler_ir, 1.0, input_items[0], zi = self.z_end)\n        return len(output_items[0])\n        \n"
    fd: fd
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import sqrt, pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1750+100
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '600'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1750+100
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '600'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '50'
    gain: ampl[0][0]*(samp_rate/100.0)
    interp: int(samp_rate/100)
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '25'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: int(samp_rate/100)
    gain: ampl[0][1]*(samp_rate/100.0)
    interp: int(samp_rate/100)
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '25'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: int(samp_rate/100)
    gain: ampl[1][1]*(samp_rate/100.0)
    interp: int(samp_rate/100)
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '25'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '50'
    gain: ampl[1][0]*(samp_rate/100.0)
    interp: int(samp_rate/100)
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '25'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '1550'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1550'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: outSigRMS
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: '2'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    max: '100'
    min: '-100'
    name: '"SNR"'
    nconnections: '3'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 2*pi*tau_a/samp_rate
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 2*pi*tau_a/samp_rate
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 2*pi*tau_a/samp_rate
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 2*pi*tau_a/samp_rate
    type: float
  states: {}
- name: snrOut
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: '4'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_const_source_x_1, '0', blocks_selector_0, '1']
- [analog_const_source_x_1_0, '0', blocks_selector_0_0, '1']
- [analog_const_source_x_1_0_0, '0', blocks_selector_0_0_0, '1']
- [analog_const_source_x_1_1, '0', blocks_selector_0_1, '1']
- [analog_const_source_x_2, '0', blocks_float_to_complex_1, '1']
- [analog_const_source_x_2_0, '0', blocks_float_to_complex_1_0, '1']
- [analog_fastnoise_source_x_0, '0', blocks_multiply_const_vxx_3, '0']
- [analog_fastnoise_source_x_0, '0', blocks_multiply_const_vxx_3_0, '0']
- [analog_fastnoise_source_x_1, '0', epy_block_0, '0']
- [analog_fastnoise_source_x_2, '0', epy_block_0_0, '0']
- [analog_fastnoise_source_x_3, '0', epy_block_0_0_0, '0']
- [analog_fastnoise_source_x_4, '0', epy_block_0_0_0_0, '0']
- [analog_noise_source_x_1, '0', low_pass_filter_2, '0']
- [analog_noise_source_x_1_0, '0', low_pass_filter_2_0, '0']
- [analog_sig_source_x_0, '0', blocks_float_to_complex_0, '0']
- [analog_sig_source_x_0, '0', blocks_float_to_complex_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0_0_0, '0', blocks_multiply_xx_0_0_1, '1']
- [analog_sig_source_x_0_0_1, '0', blocks_multiply_xx_0_1, '1']
- [analog_sig_source_x_0_1, '0', blocks_float_to_complex_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '0']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_1_0, '0']
- [analog_sig_source_x_2, '0', blocks_multiply_xx_0_0_0_0_0, '1']
- [analog_sig_source_x_2_0, '0', blocks_multiply_xx_0_0_0_0_0_0, '1']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0_0, '0']
- [audio_source_1, '0', blocks_float_to_complex_0, '0']
- [audio_source_1, '0', blocks_float_to_complex_0_0, '0']
- [audio_source_2, '0', blocks_float_to_complex_0, '0']
- [audio_source_2, '1', blocks_float_to_complex_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_add_xx_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_add_xx_0_0_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_add_xx_0_1, '0', blocks_multiply_xx_1_0, '1']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_mag_squared_2, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_mag_squared_2_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_complex_to_mag_squared_2_0_0, '0', single_pole_iir_filter_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_2_1, '0', single_pole_iir_filter_xx_0_1, '0']
- [blocks_complex_to_real_0, '0', blocks_add_xx_1, '0']
- [blocks_complex_to_real_0_0, '0', blocks_add_xx_1_0, '1']
- [blocks_delay_0, '0', blocks_multiply_xx_0_0_0_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_xx_0_0_0_0_1, '0']
- [blocks_divide_xx_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_divide_xx_1_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_float_to_complex_1, '0', blocks_multiply_xx_0_0_0_0_0, '2']
- [blocks_float_to_complex_1_0, '0', blocks_multiply_xx_0_0_0_0_0_0, '2']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_1, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_rms_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_rms_xx_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_float_to_complex_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_float_to_complex_1_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_multiply_const_vxx_3, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_3_0, '0', blocks_add_xx_1_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_delay_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_rms_xx_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0_0_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_xx_0_0_0_0_0, '0', blocks_complex_to_mag_squared_2_0, '0']
- [blocks_multiply_xx_0_0_0_0_0_0, '0', blocks_add_xx_0_0_0, '1']
- [blocks_multiply_xx_0_0_0_0_0_0, '0', blocks_complex_to_mag_squared_2_0_0, '0']
- [blocks_multiply_xx_0_0_0_0_1, '0', blocks_add_xx_0_1, '1']
- [blocks_multiply_xx_0_0_0_1, '0', blocks_add_xx_0_1, '0']
- [blocks_multiply_xx_0_0_1, '0', blocks_delay_0_0, '0']
- [blocks_multiply_xx_0_0_1, '0', blocks_multiply_xx_0_0_0_1, '0']
- [blocks_multiply_xx_0_0_1, '0', blocks_rms_xx_0_1, '0']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_mag_squared_2, '0']
- [blocks_multiply_xx_1_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_multiply_xx_1_0, '0', blocks_complex_to_mag_squared_2_1, '0']
- [blocks_nlog10_ff_0, '0', blocks_streams_to_vector_0, '2']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_streams_to_vector_0, '3']
- [blocks_rms_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_rms_xx_0_0, '0', blocks_streams_to_vector_0_0, '0']
- [blocks_rms_xx_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_rms_xx_0_0_0, '0', blocks_streams_to_vector_0_0, '1']
- [blocks_rms_xx_0_0_0, '0', qtgui_time_sink_x_0_1_0, '1']
- [blocks_rms_xx_0_1, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_selector_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_selector_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_selector_0_0, '0', blocks_multiply_xx_0_0_0_0, '1']
- [blocks_selector_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_selector_0_0_0, '0', blocks_multiply_xx_0_0_0_0_1, '1']
- [blocks_selector_0_1, '0', blocks_multiply_xx_0_0_0_1, '1']
- [blocks_streams_to_vector_0, '0', snrOut, '0']
- [blocks_streams_to_vector_0_0, '0', outSigRMS, '0']
- [epy_block_0, '0', low_pass_filter_1, '0']
- [epy_block_0_0, '0', low_pass_filter_1_0, '0']
- [epy_block_0_0_0, '0', low_pass_filter_1_1, '0']
- [epy_block_0_0_0_0, '0', low_pass_filter_1_0_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_xx_0_0_1, '0']
- [low_pass_filter_1, '0', blocks_selector_0, '0']
- [low_pass_filter_1_0, '0', blocks_selector_0_0, '0']
- [low_pass_filter_1_0_0, '0', blocks_selector_0_0_0, '0']
- [low_pass_filter_1_1, '0', blocks_selector_0_1, '0']
- [low_pass_filter_2, '0', blocks_multiply_xx_0_0_0_0_0, '0']
- [low_pass_filter_2, '0', qtgui_time_sink_x_0, '1']
- [low_pass_filter_2_0, '0', blocks_multiply_xx_0_0_0_0_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_divide_xx_1, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_streams_to_vector_0, '0']
- [single_pole_iir_filter_xx_0, '0', qtgui_number_sink_0, '1']
- [single_pole_iir_filter_xx_0, '0', qtgui_time_sink_x_0_1, '1']
- [single_pole_iir_filter_xx_0_0, '0', blocks_divide_xx_1, '1']
- [single_pole_iir_filter_xx_0_0, '0', blocks_streams_to_vector_0, '1']
- [single_pole_iir_filter_xx_0_0, '0', qtgui_number_sink_0, '2']
- [single_pole_iir_filter_xx_0_0, '0', qtgui_time_sink_x_0_1, '2']
- [single_pole_iir_filter_xx_0_0_0, '0', blocks_divide_xx_1_0, '1']
- [single_pole_iir_filter_xx_0_1, '0', blocks_divide_xx_1_0, '0']

metadata:
  file_format: 1
